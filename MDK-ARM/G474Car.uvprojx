# Keil uVision project G474Car.uvprojx, settings and files
target G474Car (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: G474Car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,USE_FULL_LL_DRIVER
  c include: ../Inc;        ../Drivers/STM32G4xx_HAL_Driver/Inc;        ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;        ../Drivers/CMSIS/Include;        ..\MDK-ARM;        ..\SensorDriver;        ..\Src\general
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/User
    ../Inc/: main.h
    ../Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group SRC
    ../Src/general/: sys.c sys.h data.c data.h DataCal.c DataCal.h dt.c dt.h Filter.c Filter.h Imu.c Imu.h Math.c Math.h Scheduler.c Scheduler.h Sensor_Basic.c Sensor_Basic.h motor.c motor.h UserCtrl.c UserCtrl.h LED.c LED.h
  group SensorDriver
    ../SensorDriver/: Drv_Spi.c Drv_Spi.h icm20602.c icm20602.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_rcc.c stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_hal_gpio.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_spi.c stm32g4xx_ll_gpio.c stm32g4xx_ll_dma.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ./: startup_stm32g474xx.s
    ../Src/: system_stm32g4xx.c
software components: CMSIS:CORE 5.1.2
